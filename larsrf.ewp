# IAR project larsrf.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
configuration UART (MSP430, debug)
  as the first configuration, except:
  group (top)
    ./: README
  group apps
    apps/: main_acktest.c main_larstest.c main_launchpad_RF.c main_uart.c
  group hal
    hal/: uart.c uart.h
  group ti
    ti/: CC1100-CC2500.c CC1100-CC2500.h include.h TI_CC_CC1100-CC2500.h TI_CC_hardware_board_launchpad.h TI_CC_msp430.h TI_CC_spi.c TI_CC_spi.h TI_CC_spi_original.c
